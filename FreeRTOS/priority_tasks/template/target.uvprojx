# Keil uVision project target.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: target
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c system.c getTaskDetails.c task1.c task_suspend_resume.c task_utility_functions.c HeapSize.c timers_oneshot_autoReload.c timer_callback.c timer_ChangePeriod.c timer_reset.c getNumberOfTasks.c taskSuspendScheduler.c mutex.c queue_overwrite.c gatekeeper_task.c priority_inversion.c deadlock.c recursive_mutex.c queue_delete.c queue_peek.c queue_reset.c event_group.c task_notify.c task_multiple_notifications.c eAction_taskNotify.c usart.c i2c.c multiple_interrupt_binary_semaphore.c binary_semaphore.c giveSemaphore_FromISR.c counting_semaphore.c deferred_daemon_task.c queue_ISR.c nested_interrupt.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Coroutines 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.1, Compiler:I/O:STDOUT 1.4.0, Device:Startup 2.6.2
