# Keil uVision project INTR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: INTR
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: interrupt_PushButton.c LED_blink_using_timer.c Usart2.c USART2_Reception.c ADC.c ADC_DMA.c Internal_Temp_Sensor_Using_DMA-ADC.c VBAT_read_using_ADC.c
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
